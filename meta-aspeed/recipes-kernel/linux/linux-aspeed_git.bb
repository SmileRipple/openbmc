# Use pull AspeedTech-BMC linux and version
#KBRANCH ?= "dev-5.4"
#LINUX_VERSION ?= "5.4.23"
KBRANCH ?= "aspeed-master-v5.1"
LINUX_VERSION ?= "5.1.3"


#SRCREV="6ba708687433a7b9e72093495721e461c8908d37"
SRCREV="466b2520fa3bbedad4da77d3eaad33d3f8838b7f"

require linux-aspeed.inc
